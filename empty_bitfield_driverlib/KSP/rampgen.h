/* =================================================================================
File name:        RAMPGEN.H
функция вычисления электрического угла магнитного поля
===================================================================================*/

#ifndef __RAMPGEN_H__
#define __RAMPGEN_H__

typedef struct {
	float  Freq; 		// 	Freq = (speedRef+sAbs)  частота поля до рампа
	float  rpm; 		// частота магнитного поля приведённая к оборотам двигателя rpm = Freq*RPMmax;
	float  StepAngleMax;// Parameter: Maximum step angle (pu)
	float  Angle;		// вычисленный угол вектора напряжения статора (0- соответствует нулю напряжения в фазе А)
	float  Out;  	 	// Output: результирующий угол вектора напряжения статора = вычисленному +ограничения
	float  radian;      //  угол вектора напряжения первой гармоники. Используется при вычислении активной мощности
	short  flag;		// признак начала нового периода поля
	float  offset;      // pu угловое смещение положения оси фазы А относительно установки датчика начала отсчёта
	float  epsv;        // (pu) угол между магнитной осью СРД и  вектором напряжения статора
	float  epsi;        // (pu) угол между магнитной осью СРД и  вектором тока статора
	float  index;       // pu угол установки датчика начала отсчёта и эл. осью статора ( соответствует Angle = 0)
	float e2;
	float em2;
	float dopusk;       // предельное отклонение вектора напряжения от магнитной оси СРД
	float manual;
	float k_AF;          // коэффициент: даёт приращение  угла поля  за один тик при частоте = 1 об/мин


	  	  	   } RAMPGEN;

/* Объяснения физического смысла параметров:
 * в любой произвольный момент времени мы имеем значение Angle и номер зуба etooth под датчиком начала отсчёта.
 * мы также знаем угол offset - угол между  датчиком index и осью фазы А статора двигателя. ???
 * мы также знаем
 * При этом при положительном направлении вращения и тот и другой параметр растёт от нуля до 1, а при противоположном
 * вращении параметры соответственно уменьшаются от 1 к нулю. Таким образом угол вектора напряжения относительно index
 * можно определить как offset = etooth
 */


/*------------------------------------------------------------------------------
      Object Initializers
------------------------------------------------------------------------------*/                       
#define RAMPGEN_DEFAULTS {0,		\
						  0,		\
						  0,		\
						  1.0f,		\
						  0,		\
						  1.0f 		\
                         }

/*------------------------------------------------------------------------------
	RAMP(Sawtooh) Generator Macro Definition
------------------------------------------------------------------------------*/                                               

#define RG_MACRO(v)									\
													\
/* Compute the angle rate */						\
	v.Angle += v.StepAngleMax * v.Freq;				\
													\
/* Saturate the angle rate within (1) */			\
	if (v.Angle > 1.0 )	v.Angle = v.Angle-1.0;		\
													\
	else 											\
	  if (v.Angle < (-1.0)) v.Angle = v.Angle+1.0;	\
													\
	v.old = v.Out;									\
	v.Out=v.Angle;

// Use the code snippet below if gain/offset needed.													\
/* Compute the ramp output */						\
	v.Out = _IQmpy(v.Angle,v.Gain) + v.Offset;		\
/* Saturate the ramp output within (-1,1) */		\
	if (v.Out>_IQ(1.0))								\
		v.Out -= _IQ(1.0);							\
	else if (v.Out<_IQ(-1.0))						\
		v.Out += _IQ(1.0);

#endif // __RAMPGEN_H__
